options:
  parameters:
    generate_options: qt_gui
    id: rx
    output_language: python
    title: Not titled yet
  states: {}

blocks:
- name: range1
  id: variable_qtgui_range
  parameters:
    orient: Qt.Horizontal
    start: '-100'
    step: '1'
    stop: '0'
    value: '-20'
  states: {}
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: analog_simple_squelch_cc_0
  id: analog_simple_squelch_cc
  parameters:
    alpha: '1'
    threshold: range1
  states: {}
- name: blocks_file_sink_0
  id: blocks_file_sink
  parameters:
    file: ./in.txt
    type: byte
    unbuffered: 'True'
  states: {}
- name: blocks_repack_bits_bb_0
  id: blocks_repack_bits_bb
  parameters:
    endianness: gr.GR_LSB_FIRST
    k: '1'
    l: '8'
  states: {}
- name: blocks_uchar_to_float_0
  id: blocks_uchar_to_float
  parameters: {}
  states: {}
- name: digital_gfsk_demod_0
  id: digital_gfsk_demod
  parameters:
    freq_error: '0.0'
    gain_mu: '0.175'
    mu: '0.5'
    omega_relative_limit: '0.005'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: osmosdr_source_0
  id: osmosdr_source
  parameters:
    bb_gain0: '20'
    freq0: 915e6
    gain0: '60'
    gain_mode0: 'False'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}
- name: qtgui_freq_sink_x_0
  id: qtgui_freq_sink_x
  parameters:
    bw: samp_rate
    fc: '0'
    fftsize: '1024'
    type: float
    wintype: firdes.WIN_BLACKMAN_hARRIS
  states: {}

connections:
- [analog_simple_squelch_cc_0, '0', digital_gfsk_demod_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_file_sink_0, '0']
- [blocks_repack_bits_bb_0, '0', blocks_uchar_to_float_0, '0']
- [blocks_uchar_to_float_0, '0', qtgui_freq_sink_x_0, '0']
- [digital_gfsk_demod_0, '0', blocks_repack_bits_bb_0, '0']
- [osmosdr_source_0, '0', analog_simple_squelch_cc_0, '0']

metadata:
  file_format: 1
