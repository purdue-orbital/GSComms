options:
  parameters:
    generate_options: qt_gui
    id: tx
    output_language: python
    run_options: run
    title: Not titled yet
  states: {}

blocks:
- name: samp_rate
  id: variable
  parameters:
    value: '32000'
  states: {}
- name: blocks_file_source_0
  id: blocks_file_source
  parameters:
    file: ./out.txt
    repeat: 'True'
    type: byte
  states: {}
- name: blocks_stream_to_tagged_stream_0
  id: blocks_stream_to_tagged_stream
  parameters:
    len_tag_key: '"packet_len"'
    packet_len: '9'
    type: byte
  states: {}
- name: digital_gfsk_mod_0
  id: digital_gfsk_mod
  parameters:
    bt: '0.35'
    samples_per_symbol: '2'
    sensitivity: '1.0'
  states: {}
- name: osmosdr_sink_0
  id: osmosdr_sink
  parameters:
    bb_gain0: '20'
    freq0: 915e6
    gain0: '64'
    if_gain0: '20'
    sample_rate: samp_rate
    sync: sync
    type: fc32
  states: {}

connections:
- [blocks_file_source_0, '0', blocks_stream_to_tagged_stream_0, '0']
- [blocks_stream_to_tagged_stream_0, '0', digital_gfsk_mod_0, '0']
- [digital_gfsk_mod_0, '0', osmosdr_sink_0, '0']

metadata:
  file_format: 1
